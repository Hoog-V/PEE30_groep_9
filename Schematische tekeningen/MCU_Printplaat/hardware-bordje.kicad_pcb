# Repository Hoog-V/PEE30_groep_9

File README.md:

# PEE30_groep_9
Het project voor het tweede jaars projectvak PEE30

## KiCad design Schematische tekeningen/MCU_Printplaat/hardware-bordje.kicad_pcb

Parts:
C3: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 1nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C7, C9: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C8: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: PESD5V0L4UW; SOT-665
D2: TX; LED_0201_0603Metric_Pad0.64x0.40mm_HandSolder
D3: RX; LED_0201_0603Metric_Pad0.64x0.40mm_HandSolder
IC1: MSP430FR2476TPTR; QFP50P900X900X160-48N; Mouser Part Number 595-MSP430FR2476TPTR
J1, J2: Conn_01x02; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
J3: IO1; PinHeader_1x06_P2.54mm_Vertical
J4: IO6; PinHeader_1x06_P2.54mm_Vertical
J5: USB_B_Mini; UJ2MBH1SMTTR
J6: IO7; PinHeader_1x05_P2.54mm_Vertical
J7: IO3; PinHeader_1x06_P2.54mm_Vertical
J8: DEBUG HDR; PinHeader_1x06_P2.54mm_Vertical
J9: IO4; PinHeader_1x06_P2.54mm_Vertical
J10: IO2; PinHeader_1x06_P2.54mm_Vertical
J11: +3.3V; PinHeader_1x03_P2.54mm_Vertical
J12: IO5; PinHeader_1x06_P2.54mm_Vertical
J13: +5V; PinHeader_1x03_P2.54mm_Vertical
R3: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 22.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 47.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R11, R12: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: Reset knop; SW_SPST_EVPBF
TP1: VIO; TestPoint_Pad_D1.5mm
TP2: CTS; TestPoint_Pad_D1.5mm
TP3: DSR; TestPoint_Pad_D1.5mm
TP4: DCD; TestPoint_Pad_D1.5mm
TP5: GPIO0.3; TestPoint_Pad_D1.5mm
TP6: RI/CLK; TestPoint_Pad_D1.5mm
TP7: RTS; TestPoint_Pad_D1.5mm
TP8: DTR; TestPoint_Pad_D1.5mm
TP9: GPIO0.2; TestPoint_Pad_D1.5mm
U1: CP2102N-A01-GQFN24; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm

Connections:
+5V: C8.1, C9.1, D1.1 (K1), J5.1 (VBUS), J13.1, R8.1, U1.7 (REGIN)
GND: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, D1.2 (A), IC1.48 (DVSS), J5.5 (GND), J5.6 (Shield), J8.6, J11.2, J11.3, J13.2, J13.3, R9.2, SW1.2, U1.2 (GND), U1.25 (GND)
I2C_SCL: IC1.15 (P1.3/UCB0SOMI/UCB0SCL/MCLK/A3), J10.4, R5.2
I2C_SDA: IC1.14 (P1.2/UCB0SIMO/UCB0SDA/TA0.2/A2/VEREF-), J10.3, R4.2
unnamed: D2.1 (K), U1.14 (GPIO.0)
unnamed: D2.2 (A), R11.1
unnamed: D3.1 (K), U1.13 (GPIO.1)
unnamed: D3.2 (A), R12.1
unnamed: R8.2, R9.1, U1.8 (VBUS)
unnamed: R10.1, U1.9 (~RSTb)
unnamed: TP2.1, U1.18 (CTS)
unnamed: TP3.1, U1.22 (DSR)
unnamed: TP4.1, U1.24 (DCD)
unnamed: TP5.1, U1.11 (GPIO.3)
unnamed: TP6.1, U1.1 (RI/CLK)
unnamed: TP7.1, U1.19 (RTS)
unnamed: TP8.1, U1.23 (DTR)
unnamed: TP9.1, U1.12 (GPIO.2)
P1.0: IC1.12 (P1.0/UCB0STE/TA0CLK/A0/VEREF+), J10.1
P1.1: IC1.13 (P1.1/UCB0CLK/TA0.1/COMP0.0/A1), J10.2
P1.6: IC1.6 (P1.6/UCA0CLK/TA1CLK/TDI/TCLK/A6), J3.1
P1.7: IC1.7 (P1.7/UCA0STE/SMCLK/TDO/A7), J3.2
P2.0: IC1.46 (P2.0/XOUT), J6.2
P2.1: IC1.47 (P2.1/XIN), J6.1
P2.2: IC1.16 (P2.2/ACLK/COMP0.1), J10.5
P2.3: IC1.25 (P2.3/TA2.0), J12.2
P2.4: IC1.28 (P2.4/UCA1CLK), J12.5
P2.5: IC1.29 (P2.5/UCA1RXD/UCA1SOMI), J12.6
P2.6: IC1.30 (P2.6/UCA1TXD/UCA1SIMO), J9.1
P2.7: IC1.36 (P2.7/UCB1STE), J9.6
P3.0: IC1.23 (P3.0/TA2.2), J7.6
P3.1: IC1.27 (P3.1/UCA1STE), J12.4
P3.2: IC1.38 (P3.2/UCB1SIMO/UCB1SDA), J4.5
P3.3: IC1.24 (P3.3/TA2.1), J12.1
P3.4: IC1.26 (P3.4/TA2CLK/COMP0OUT), J12.3
P3.5: IC1.37 (P3.5/UCB1CLK/TB0TRG), J4.6
P3.6: IC1.39 (P3.6/UCB1SOMI/UCB1SCL), J4.4
P3.7: IC1.32 (P3.7/TA3.2), J9.2
P4.0: IC1.33 (P4.0/TA3.1), J9.3
P4.1: IC1.34 (P4.1/TA3.0), J9.4
P4.2: IC1.35 (P4.2/TA3CLK), J9.5
P4.3: IC1.8 (P4.3/UCB1SOMI/UCB1SCL/TB0.5/A8), J3.3
P4.4: IC1.9 (P4.4/UCB1SIMO/UCB1SDA/TB0.6/A9), J3.4
P4.5: IC1.17 (P4.5/UCB0SOMI/UCB0SCL/TA3.2), J10.6
P4.6: IC1.18 (P4.6/UCB0SIMO/UCB0SDA/TA3.1), J7.1
P4.7: IC1.42 (P4.7/UCA0STE/TB0.1), J4.1
P5.0: IC1.43 (P5.0/UCA0CLK/TB0.2), J6.5
P5.1: IC1.44 (P5.1/UCA0RXD/UCA0SOMI/TB0.3), J6.4
P5.2: IC1.45 (P5.2/UCA0TXD/UCA0SIMO/TB0.4), J6.3
P5.3: IC1.10 (P5.3/UCB1CLK/TA3.0/A10), J3.5
P5.4: IC1.11 (P5.4/UCB1STE/TA3CLK/A11), J3.6
P5.5: IC1.19 (P5.5/UCB0CLK/TA2CLK), J7.2
P5.6: IC1.20 (P5.6/UCB0STE/TA2.0), J7.3
P5.7: IC1.21 (P5.7/TA2.1/COMP0.2), J7.4
P6.0: IC1.22 (P6.0/TA2.2/COMP0.3), J7.5
P6.1: IC1.40 (P6.1/TB0CLK), J4.3
P6.2: IC1.41 (P6.2/TB0.0), J4.2
RST-SWBTDIO: C4.1, IC1.2 (~RST~/NMI/SBWTDIO), J8.4, R3.2, SW1.1
RXD: J1.1, U1.20 (RXD)
RXD_MCU: IC1.5 (P1.5/UCA0RXD/UCA0SOMI/TA1.1/TMS/A5), J2.1, J8.3
SBWTCK: IC1.3 (TEST/SBWTCK), J8.5
TXD: J2.2, U1.21 (TXD)
TXD_MCU: IC1.4 (P1.4/UCA0TXD/UCA0SIMO/TA1.2/TCK/A4/VREF+), J1.2, J8.2
USB_DM: D1.4 (K3), J5.2 (D-), U1.4 (D-)
USB_DP: D1.3 (K2), J5.3 (D+), U1.3 (D+)

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
Board: 2 copper layers, 34.8 x 36.5 mm, 43 parts (19 on the bottom side), 66 nets.

## KiCad design Schematische tekeningen/printplaat TTL/PCB_PEE30 zonder mountingholes.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2: Screw_Terminal_01x02; SolderWire-0.5sqmm_1x02_P4.8mm_D0.9mm_OD2.3mm
R1, R3, R4, R5, R6, R7, R8, R9, R10: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TTL_MSP-kant_1: Screw_Terminal_01x03; SolderWire-0.5sqmm_1x03_P4.8mm_D0.9mm_OD2.3mm
TTL_MSP-kant_2: Screw_Terminal_01x02; SolderWire-0.5sqmm_1x02_P4.8mm_D0.9mm_OD2.3mm
TTL_Output1: Screw_Terminal_01x02; SolderWire-0.5sqmm_1x02_P4.8mm_D0.9mm_OD2.3mm
U1: Testcomponent_PEE30; SO-14_3.9x8.65mm_P1.27mm
U2, U3, U4, U7, U8: PC817; DIP-4_W7.62mm
input_TTL1: Screw_Terminal_01x03; SolderWire-0.5sqmm_1x03_P4.8mm_D0.9mm_OD2.3mm

Connections:
+3.3VP: J2.1, R2.1, R4.1
+3V3: J1.1, R5.1, R6.1, R7.1, U1.14
GND1: J1.2, U1.7, U2.3, U3.3, U4.3, U7.2, U8.2
GNDS: J2.2, U2.2, U3.2, U4.2, U7.3, U8.3
In1: R6.2, U1.1, U3.4
In2: R5.2, U1.5, U2.4
In3: R7.2, U1.9, U4.4
unnamed: R1.1, TTL_MSP-kant_2.2
unnamed: R1.2, U7.1
unnamed: R2.2, TTL_Output1.1, U7.4
unnamed: R3.1, TTL_MSP-kant_2.1
unnamed: R3.2, U8.1
unnamed: R4.2, TTL_Output1.2, U8.4
unnamed: R8.1, input_TTL1.1
unnamed: R8.2, U2.1
unnamed: R9.1, input_TTL1.2
unnamed: R9.2, U3.1
unnamed: R10.1, input_TTL1.3
unnamed: R10.2, U4.1
Out1: TTL_MSP-kant_1.3, U1.2
Out2: TTL_MSP-kant_1.2, U1.6
Out3: TTL_MSP-kant_1.1, U1.8

Board: 2 copper layers, 61.0 x 48.3 mm, 26 parts (0 on the bottom side), 22 nets.

## KiCad design Schematische tekeningen/Voeding/Voeding.kicad_pcb

Board: 2 copper layers, 66.2 x 52.9 mm, 66 parts (5 on the bottom side), 33 nets.

Parts:
C1, C5, C11, C12, C13: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 470u; CP_Radial_D10.0mm_P5.00mm
C3: 220u; CP_Radial_D10.0mm_P5.00mm
C4: 100uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C6: 1n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8: 22uF; CP_Radial_D5.0mm_P2.50mm
C9: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10: 3.3nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1: 20V; D_SOD-323_HandSoldering
D2: CMHD4448; D_PowerDI-123
D3: ss310; D_SMC_Handsoldering
D4: SS310; D_SOD-123F
D5: 3.6V zener; D_SOD-123
D6: SS510; D_SMC_Handsoldering
F1: 50mA fuse; Fuse_0603_1608Metric
FB1: Ferriete kraal; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
J1: VCC; TestPoint_Plated_Hole_D3.0mm
J2, J6: GND; TestPoint_Plated_Hole_D3.0mm
J3: GNDS; TestPoint_Plated_Hole_D3.0mm
J4: +3.3V_ISO; TestPoint_Plated_Hole_D3.0mm
J5: +3.3V; TestPoint_Plated_Hole_D3.0mm
J7: MCU_RST; PinHeader_1x01_P2.54mm_Vertical
J8: Fault_signals; PinHeader_1x03_P2.54mm_Vertical
L1: 68u; L_10.4x10.4_H4.8
L2: 10uH; WE-TPC_4818_482892
Q1: FDN340P; SOT-23
Q2: 2N7002; SOT-23
R1: 232k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 806k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 44k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R7, R8, R9, R10, R11, R12: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R13, R16, R17, R18, R19, R20: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 620; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14, R15: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
T1: Transformer_1P_2S_WE_750313973; 750313973
U1: LT8301IS5TRPBF; Linear_Technology-LT8301IS5TRPBF-Level_A
U2: LM2596S-ADJ; TO-263-5_TabPin3
U3: APX803L-3.3; APX803-46SAG-7
U4: APX803L-3.9; APX803-46SAG-7
U5, U6: 74LVC1G58; SOT-363_SC-70-6_Handsoldering
U7: 74LVC1G58_C; SOT-363_SC-70-6_Handsoldering
U8, U9: APX803-46SAG-7
U10, U11, U12: PC817; DIP-4_W7.62mm

Connections:
3.3UVLO: R14.1, R16.2, U7.6, U8.2
3.3UVLO_m: J7.1, R8.1, U4.2, U5.6
3.9OVLO: R15.1, R18.2, U7.1, U9.2
3.9OVLO_m: R7.1, U3.2, U5.1
+3.3VA: J5.1, Q1.2, R17.1, R19.1, R20.1
+3.3VP: C11.1, C12.1, C13.1, F1.1, J4.1, R13.1, R14.2, R15.2, U7.5, U8.3, U9.3
+3.3V_ISO_UV: J8.2, R17.2, U11.4
+3.3V_ISO_present: J8.3, R20.2, U10.4
+3V3: C3.1, L1.2, Q1.3, R5.1, R7.2, R8.2, R10.1, R11.2, U3.3, U4.3, U5.5, U6.1, U6.5
Earth: C4.2, C5.2, C6.2, C10.1, C11.2, C12.2, C13.2, D5.2, Q2.2, R12.2, T1.7, T1.8, U7.2, U7.3, U8.1, U9.1, U10.2, U11.2, U12.2
GND: C1.2, C2.2, C3.2, C7.2, C8.2, C9.2, C10.2, D3.2, J2.1, J6.1, R2.2, R6.2, R9.2, U1.2, U2.3, U2.5, U3.1, U4.1, U5.2, U5.3, U6.2, U10.3, U11.3, U12.3
unnamed: C4.1, C5.1, C6.1, D4.1, D5.1, F1.2
unnamed: C7.1, FB1.1, L2.1
unnamed: C8.1, C9.1, D1.2, L2.2, R1.1, T1.4, U1.5
unnamed: D1.1, D2.1
unnamed: D2.2, R4.1, T1.1, U1.4
unnamed: D3.1, L1.1, U2.2
unnamed: D4.2, T1.5, T1.6
unnamed: D6.2, J1.1
unnamed: J3.1, Q2.3
unnamed: R1.2, R2.1, U1.1
unnamed: R3.1, R4.2
unnamed: R3.2, U1.3
unnamed: R9.1, U5.4, U6.6
unnamed: R10.2, U6.3
unnamed: R13.2, U10.1
unnamed: R16.1, U11.1
unnamed: R18.1, U12.1
UVL_OVL_3.3_m_MOSF: Q1.1, R11.1, U6.4
UVL_OVL_MOSF: Q2.1, R12.1, U7.4
VDC: C1.1, C2.1, D6.1, FB1.2, U2.1
V_FB: R5.2, R6.1, U2.4
~3.3V_ISO_OV: J8.1, R19.2, U12.4

## Commit log

2021-11-25 Inhoud bitbucket gemigreerd
2021-11-25 Mappenstructuur iets aangepast
2021-11-25 Noodstop was verloren gegaan
2021-11-25 Footprints toegevoegd en toegewezen. Tekening weer iets aangepast
2021-12-02 Footprints aangepast. Tekening aangepast
2021-12-09 Printplaat voeding af!
2021-12-09 Gaten toevoegen aan printplaat voeding
2021-12-10 PCB TTL isolatie
    PCB isolatie gemaakt
2021-12-10 Gerbers geexporteerd voor de voeding printplaat
2021-12-10 Gerbers geexporteerd voor de ttl printplaat
2021-12-12 Code opzetje gemaakt. ADC metingen, UART, I2C en PWM timers toegevoegd
2021-12-12 Code getest! Adc stappen geschaald naar spanning setpoint
2021-12-19 Totaalschema in orde maken

Notices in the files:
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
